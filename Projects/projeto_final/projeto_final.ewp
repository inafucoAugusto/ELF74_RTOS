# IAR project projeto_final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\drivers; D:\Facul\Embarcados\ELF74\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: projeto_final.srec
  ILINK.IlinkOutputFile: projeto_final.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: desafio.c driverbuttons.c driverbuttons.h driverleds.c driverleds.h driverlib.a RTX_CM.a RTX_Config.c rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c
